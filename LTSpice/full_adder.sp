* This file represents the description of a full adder.
* The SPICE list was generated by SwitchCraft.
.include ams35ps.lib

V0 gnd 0 DC 0V
V1 vcc 0 DC 3.3V

* The inputs are: a, b, c (carry in)
Vin1 c gnd pulse (0 3.3 0n 0.1n 0.1n 20n 40.2n)
Vin2 b gnd pulse (0 3.3 0n 0.1n 0.1n 40.1n 80.4n)
Vin3 a gnd pulse (0 3.3 0n 0.1n 0.1n 80.3n 160.8n)

* XOR 3
.SUBCKT XOR3 a b c out VDD GND
*.PININFO a:I b:I c:I out:O VDD:P GND:G
*.EQN out=((b * !c * !a) + (!b * c * !a) + (b * c * a) + (!b * !c * a));
MP1 out a pu_n1 VDD MODP W=2.2u L=0.3u
MP2 out not_a pu_n3 VDD MODP W=2.2u L=0.3u
MP3 pu_n1 c pu_n4 VDD MODP W=2.2u L=0.3u
MP4 pu_n1 not_c pu_n5 VDD MODP W=2.2u L=0.3u
MP5 pu_n4 not_b VDD VDD MODP W=2.2u L=0.3u
MP6 pu_n5 b VDD VDD MODP W=2.2u L=0.3u
MP7 pu_n3 c pu_n5 VDD MODP W=2.2u L=0.3u
MP8 pu_n3 not_c pu_n4 VDD MODP W=2.2u L=0.3u
MN9 out not_a pd_n1 GND MODN W=1.2u L=0.3u
MN10 out a pd_n3 GND MODN W=1.2u L=0.3u
MN11 pd_n1 not_c pd_n4 GND MODN W=1.2u L=0.3u
MN12 pd_n1 c pd_n5 GND MODN W=1.2u L=0.3u
MN13 pd_n4 not_b GND GND MODN W=1.2u L=0.3u
MN14 pd_n5 b GND GND MODN W=1.2u L=0.3u
MN15 pd_n3 not_c pd_n5 GND MODN W=1.2u L=0.3u
MN16 pd_n3 c pd_n4 GND MODN W=1.2u L=0.3u
MP_inv17 not_a a VDD VDD MODP W=2.2u L=0.3u
MN_inv18 not_a a GND GND MODN W=1.2u L=0.3u
MP_inv19 not_b b VDD VDD MODP W=2.2u L=0.3u
MN_inv20 not_b b GND GND MODN W=1.2u L=0.3u
MP_inv21 not_c c VDD VDD MODP W=2.2u L=0.3u
MN_inv22 not_c c GND GND MODN W=1.2u L=0.3u
.ENDS XOR3

* carry out
.SUBCKT C_OUT a b c not_out VDD GND
*.PININFO a:I b:I c:I not_out:O VDD:P GND:G
*.EQN not_out=!((!c * !a) + (!b * !c) + (!b * c * !a));
MP1 out a pu_n1 VDD MODP W=2.2u L=0.3u
MP2 pu_n1 c VDD VDD MODP  W=2.2u L=0.3u
MP3 pu_n1 not_c pu_n4 VDD MODP  W=2.2u L=0.3u
MP4 pu_n4 b VDD VDD MODP  W=2.2u L=0.3u
MP5 out c pu_n4 VDD MODP  W=2.2u L=0.3u
MN6 out a pd_n1 GND MODN  W=1.2u L=0.3u
MN7 out c pd_n3 GND MODN W=1.2u L=0.3u
MN8 pd_n3 b GND GND MODN W=1.2u L=0.3u
MN9 pd_n1 not_c pd_n3 GND MODN W=1.2u L=0.3u
MN10 pd_n1 c GND GND MODN W=1.2u L=0.3u
MP_inv11 not_c c VDD VDD MODP W=2.2u L=0.3u
MN_inv12 not_c c GND GND MODN W=1.2u L=0.3u
MP_inv13 not_out out VDD VDD MODP W=2.2u L=0.3u
MN_inv14 not_out out GND GND MODN W=1.2u L=0.3u
.ENDS C_OUT

* Call for the subckts
X1 a b c s vcc gnd XOR3
X2 a b c co vcc gnd C_OUT

* The output signal is: s
* The carry-out signal is: co

.tran 0.0002ns 200ns

.probe

.end
